# Keil uVision project Bluetooth_Music.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bluetooth_Music +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\freertos\port\include;..\freertos\port\RVDS;..\user;..\STM32F10x_StdPeriph_Driver\inc;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c bsp_gpio.h bsp_gpio.c bsp_system_init.c bsp_system_init.h FreeRTOSConfig.h stm32f10x_it.c stm32f10x_it.h main_freertos.c vs1053.c vs1053.h bsp_uart.c bsp_uart.h bsp_dma.c bsp_dma.h mp3.c
  group FreeRTOS/src
    ../freertos/src/: queue.c croutine.c event_groups.c list.c stream_buffer.c tasks.c timers.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h stm32f10x_conf.h
  group Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_dma.c
    ../STM32F10x_StdPeriph_Driver/inc/: stm32f10x_rcc.h stm32f10x_gpio.h stm32f10x_spi.h stm32f10x_usart.h stm32f10x_dma.h
  group FreeRTOS/port
    ../freertos/port/RVDS/: port.c portmacro.h
    ../freertos/port/MemMang/: heap_4.c
    ../FreeRTOS/port/include/: semphr.h queue.h
